## package/libaudioshim/Config.in
```kconfig
config BR2_PACKAGE_LIBAUDIOSHIM
	bool "libaudioshim"
	help
	  Shared library patching libaudioProcess.so
```
